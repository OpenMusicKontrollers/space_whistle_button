# Repository OpenMusicKontrollers/space_whistle_button

File README.md:

# Space Whistle Expressive Button

## About
This is the PCB design for the expressive button for the [Space Whistle](http://hackaday.io/project/2011-Space-Whistle) - an expressive open wind controller.

## Prerequisites
To be used with [KiCAD](http://www.kicad-pcb.org).

## License
This is open source hardware and licensed under [CERN OHL v.1.2](http://ohwr.org/cernohl).

## KiCad design space_whistle_button.kicad_pcb

Parts:
C1, C2: 10uF
C3, C6, C7: 1uF
C4, C5: 0.1uF
K1: CONN_3
R1: 20k
RV1: 500
RV2: 200k
S1: A1304; MODULE
U1: MCP1703
U2: MCP601

Connections:
+3.3V: C2.1, C3.2, C4.2, C5.2, C6.2, RV1.1, S1.1, U1.2 (VO), U2.7 (V+)
+5V: C1.1, K1.1, U1.1 (VI)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, K1.2 (PM), RV1.3, S1.2, U1.3 (GND), U2.4 (V-)
unnamed: K1.3, RV2.2, RV2.3, U2.6
unnamed: C7.2, R1.1, RV1.2
unnamed: R1.2, RV2.1, U2.2 (-)
unnamed: S1.3, U2.3 (+)

Notes on the sheet:
linear hall effect sensor
low dropout voltage regulator
non-inverting OpAmp with adjustable offset (RV1) and gain (RV2)

Board: 2 copper layers, 20.0 x 20.0 mm, 18 parts (0 on the bottom side), 7 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## Commit log

2014-07-30 paste dims
2014-07-30 set origin
2014-08-04 add Digi-Key part numbers

Notices in the files:
space_whistle_button.kicad_pcb:
Released under CERN OHL v.1.2
Copyright (c) 2014 Hanspeter Portner (dev@open-music-kontrollers.ch)
